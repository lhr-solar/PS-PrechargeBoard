File: Isolated_Amplifier.kicad_sch (KiCad schematic)
At the start: 12 parts

Commit message: AGND
Parts:
- gave numbers to parts that had none: 12
Connections:
- net GND renamed AGND
